options:
  parameters:
    author: prakhar
    generate_options: qt_gui
    id: task_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\OneDrive - Indian Institute of Technology Bombay\Desktop\SEM6\EE 340 (L)\Lab-2\lab2_task2.dat
    repeat: 'True'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '16000'
    decim: '20'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: tab@1
    type: float
    wintype: firdes.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: tab@0
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab@1
    size: '1024'
    srate: '48000'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: tab@0
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: 'Modulated '
    label1: Demodulated
    num_tabs: '2'
  states: {}

connections:
- [blocks_abs_xx_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0, '0', blocks_abs_xx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
