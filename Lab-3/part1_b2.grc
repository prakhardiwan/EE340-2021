options:
  parameters:
    author: prakhar
    generate_options: qt_gui
    id: part1_b2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3528000'
  states: {}
- name: samp_rate_msg
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_msg
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/prakhar/Desktop/EE_340/Lab-3/task2b.dat
    repeat: 'True'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1,-1]'
    type: fff
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1, -0.95]'
    fftaps: '[1]'
    type: ffd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '80'
    gain: '100'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_msg
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}

connections:
- [blocks_abs_xx_0, '0', low_pass_filter_0, '0']
- [blocks_abs_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_imag_0, '0', fir_filter_xxx_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_0, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', qtgui_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_abs_xx_0, '0']
- [iir_filter_xxx_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', iir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', iir_filter_xxx_0, '0']

metadata:
  file_format: 1
