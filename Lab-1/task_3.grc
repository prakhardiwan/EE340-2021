options:
  parameters:
    author: prakhar
    generate_options: qt_gui
    id: task_3
    output_language: python
    title: top_block
  states: {}

blocks:
- name: gain1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: gain3
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: gain4
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: gain5
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain3
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain2
    high_cutoff_freq: '3000'
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain1
    high_cutoff_freq: '500'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain5
    high_cutoff_freq: '15000'
    low_cutoff_freq: '9000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_4
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: gain4
    high_cutoff_freq: '9000'
    low_cutoff_freq: '6000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '7'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/prakhar/Desktop/EE_340/Lab-1/Bach.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    type: float
    wintype: firdes.WIN_RECTANGULAR
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '3']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '2']
- [band_pass_filter_1, '0', blocks_add_xx_0, '1']
- [band_pass_filter_3, '0', blocks_add_xx_0, '5']
- [band_pass_filter_4, '0', blocks_add_xx_0, '4']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_3, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_4, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [high_pass_filter_0, '0', blocks_add_xx_0, '6']
- [low_pass_filter_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
