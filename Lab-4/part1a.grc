options:
  parameters:
    author: prakhar
    generate_options: qt_gui
    id: part1a
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Vt
  id: variable
  parameters:
    value: '25e-3'
  states: {}
- name: k
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: mult_ip_k
  id: variable_qtgui_range
  parameters:
    label: mult_ip_k
    orient: Qt.Horizontal
    start: '0'
    step: '10e-5'
    stop: '100e-3'
    value: '10e-6'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: '41000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\OneDrive - Indian Institute of Technology Bombay\Desktop\SEM6\EE 340 (L)\Lab-4\Input.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mult_ip_k
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (-1)/(2*Vt)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: k
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: exp
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_divide_xx_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', band_pass_filter_0, '0']
- [blocks_divide_xx_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_transcendental_0, '0', blocks_multiply_const_vxx_0_1, '0']

metadata:
  file_format: 1
